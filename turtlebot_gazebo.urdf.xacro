Commit message: Update turtlebot_gazebo.urdf.xacro

File: turtlebot_gazebo.urdf.xacro (robot description, xacro)
@@ -69,4 +69,4 @@
       </sensor>
     </gazebo>
-	</xacro:macro>
+  </xacro:macro>
 </robot>
